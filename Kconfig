## Kconfig
```kconfig
menuconfig SHT21
	bool "SHT21 Temperature and Humidity Sensor"
	depends on I2C
	help
	  Enable driver for SHT21 temperature and humidity sensors.
```
